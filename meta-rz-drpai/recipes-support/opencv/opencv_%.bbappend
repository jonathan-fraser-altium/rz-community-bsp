PACKAGECONFIG:append_pn-opencv = " gtk"
PACKAGECONFIG:append_pn-nativesdk-opencv = " gtk"
