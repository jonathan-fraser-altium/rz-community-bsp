DESCRIPTION = "CIP SLTS Linux kernel v6.1"

require linux.inc

KERNEL_URL = "git://github.com/jonathan-fraser-altium/linux.git"
KBRANCH = "v6.1_drpai"
SRCREV = "0ef80cd78a5b37db4c15bc5ebfc83bf351bb1361"

LINUX_VERSION = "6.1"